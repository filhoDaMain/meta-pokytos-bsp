# do_deploy:append() {
#     cp ${B}/u-boot.bin ${DEPLOY_DIR_IMAGE}/
# }
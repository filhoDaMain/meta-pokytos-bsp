FILESEXTRAPATHS:append := "${THISDIR}/files:"
include ${PN}/include/${SOC_FAMILY}.inc
